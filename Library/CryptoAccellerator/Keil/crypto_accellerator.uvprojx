# Keil uVision project crypto_accellerator.uvprojx, settings and files
target mbedcrypto (6150000::V6.15::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.15
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ..\mbedcrypto (library)
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c define: MBEDTLS_CONFIG_FILE=mbedtls_config.h
  c include: ..\..\CMSIS\Include;..\..\Device\Nuvoton\m460\Include;..\..\StdDriver\inc;..\..\CryptoAccellerator;..\..\..\ThirdParty\mbedtls-3.1.0\include;..\..\..\ThirdParty\mbedtls-3.1.0\library
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group crypto_accellerator
    ../: aes_alt.c ccm_alt.c ecdh_alt.c ecdsa_alt.c ecp_internal_alt.c gcm_alt.c rsa_alt.c sha256_alt.c trng_api.c mbedtls_config.h platform_alt.c
  group mbedcrypto
    ../../../ThirdParty/mbedtls-3.1.0/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c ssl_debug_helpers_generated.c threading.c timing.c version.c version_features.c
