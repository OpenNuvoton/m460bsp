# Keil uVision project LwIP_UDP_EchoServer.uvprojx, settings and files
target LwIP_UDP_EchoServer (6120000::V6.12::.\ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: LwIP_UDP_EchoServer +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\;..\..\..\..\ThirdParty\lwIP\src\include;..\..\lwIP\include;..\..\..\..\Library\CMSIS\Include;..\..\lwIP\drv_emac
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group User
    ../: main.c udp_echoserver-netconn.c
  group drv_emac
    ../../lwIP/drv_emac/: m460_emac.c m460_mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c QueueSet.c semtest.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c
  group lwIP
    ../../lwIP/: sys_arch.c time_stamp.c
    ../../lwIP/netif/: ethernetif.c
    ../../../../ThirdParty/lwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwIP/src/netif/: ethernet.c
