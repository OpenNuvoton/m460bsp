# Keil uVision project LwIP_SSL_Client.uvprojx, settings and files
target LwIP_SSL_Client (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.15
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: LwIP_SSL_Client +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: MBEDTLS_CONFIG_FILE=<ssl_config.h>
  c misc: --diag_suppress=550,177,C4017,111,66
  c include: ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include;..\..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\DEMO\COMMON\include;..\..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\;..\..\..\..\ThirdParty\lwip\src\include;..\..\lwip\include;..\..\..\..\Library\CMSIS\Include;..\..\lwip\drv_emac;..\..\..\..\ThirdParty\mbedtls-2.13.0\include
  asm define: Stack_Size=0x1000 Heap_Size=0xd000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group User
    ../: main.c ssl_client.c net_sockets.c
  group drv_emac
    ../../lwIP/drv_emac/: m460_emac.c m460_emac_process.c m460_mii.c synopGMAC_Dev.c synopGMAC_network_interface.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: list.c tasks.c timers.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c semtest.c QueueSet.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c crypto.c
  group LwIP
    ../../lwip/: sys_arch.c time_stamp.c
    ../../lwip/netif/: ethernetif.c
    ../../../../ThirdParty/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwip/src/netif/: ethernet.c
  group mbedtls
    ../../../../ThirdParty/mbedtls-2.13.0/library/: entropy.c ssl_tls.c certs.c sha256.c x509_crt.c sha512.c x509.c md.c pk.c pk_wrap.c md_wrap.c oid.c ecdh.c md5.c dhm.c ecp.c rsa.c ripemd160.c bignum.c asn1parse.c ecdsa.c pem.c des.c aes.c hmac_drbg.c base64.c asn1write.c sha1.c ctr_drbg.c ssl_cache.c cipher.c chachapoly.c gcm.c chacha20.c ccm.c rsa_internal.c poly1305.c pkparse.c platform_util.c pkcs5.c pkcs11.c pkcs12.c ecp_curves.c arc4.c ssl_srv.c ssl_cli.c ssl_ciphersuites.c cipher_wrap.c camellia.c blowfish.c entropy_poll.c debug.c
