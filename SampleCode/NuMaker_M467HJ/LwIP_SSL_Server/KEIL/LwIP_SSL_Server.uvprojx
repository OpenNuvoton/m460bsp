# Keil uVision project LwIP_SSL_Server.uvprojx, settings and files
target LwIP_SSL_Server (6190000::V6.19::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: LwIP_SSL_Server +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3
  c define: MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c misc: -Wno-visibility
  c include: ..\..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include;..\..\..\..\ThirdParty\FreeRTOS\DEMO\COMMON\include;..\..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\GCC\ARM_CM4F;..\;..\..\..\..\ThirdParty\lwip\src\include;..\..\lwip\include;..\..\..\..\Library\CMSIS\Include;..\..\lwip\drv_emac;..\..\..\..\ThirdParty\mbedtls-3.1.0\include;..\..\..\..\ThirdParty\mbedtls-3.1.0\library;..\..\..\..\ThirdParty\mbedtls-3.1.0\tests\include
  asm define: Stack_Size=0x1000 Heap_Size=0xd000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group User
    ../: main.c ssl_server.c net_sockets.c
  group drv_emac
    ../../lwIP/drv_emac/: m460_emac.c m460_mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: list.c tasks.c timers.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c semtest.c QueueSet.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c
  group LwIP
    ../../lwip/: sys_arch.c time_stamp.c
    ../../lwip/netif/: ethernetif.c
    ../../../../ThirdParty/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwip/src/netif/: ethernet.c
  group mbedtls
    ../../../../ThirdParty/mbedtls-3.1.0/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
    ../../../../ThirdParty/mbedtls-3.1.0/tests/src/: certs.c
