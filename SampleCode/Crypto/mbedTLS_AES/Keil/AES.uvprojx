# Keil uVision project AES.uvprojx, settings and files
target AES (6180000::V6.18::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: mbedtls_aes
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: MBEDTLS_CONFIG_FILE=mbedtls_config.h
  c include: ..\..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\mbedTLS\include\mbedtls;..\;..\..\..\..\Library\CryptoAccelerator;..\..\..\..\ThirdParty\mbedtls-3.1.0\include;..\..\..\..\ThirdParty\mbedtls-3.1.0\library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
    ../../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c
    ../../../../Library/CryptoAccelerator/Keil/: mbedcrypto.lib
