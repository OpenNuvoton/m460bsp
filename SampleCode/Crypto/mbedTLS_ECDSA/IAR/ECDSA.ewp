# IAR project ECDSA.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxJHAE series Nuvoton M46xxJHAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; MBEDTLS_CONFIG_FILE=mbedtls_config.h
  ICCARM.CCDiagSuppress: Pe188,Pe549
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\m460\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\mbedtls-3.1.0\include; ..\; ..\..\..\..\ThirdParty\mbedtls-3.1.0\library; ..\..\..\..\Library\CryptoAccelerator; ..\..\..\..\ThirdParty\mbedtls-3.1.0\tests\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AES.bin
  ILINK.IlinkOutputFile: AES.out
  ILINK.IlinkIcfFile: iar.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_m460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group mbedtls
    ../../../../ThirdParty/mbedtls-3.1.0/tests/src/: helpers.c psa_crypto_helpers.c random.c
    ../../../../Library/CryptoAccelerator/IAR/: mbedcrypto.a
  group User
    ../: test_suite_ecdsa.c
