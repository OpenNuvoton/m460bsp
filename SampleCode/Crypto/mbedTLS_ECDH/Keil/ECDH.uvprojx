# Keil uVision project ECDH.uvprojx, settings and files
target ECDH (6180000::V6.18::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ECDH
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: MBEDTLS_CONFIG_FILE=mbedtls_config.h
  c include: ..\..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CryptoAccelerator;..\..\..\..\ThirdParty\mbedtls-3.1.0\include;..\..\..\..\ThirdParty\mbedtls-3.1.0\library;..\..\..\..\ThirdParty\mbedtls-3.1.0\tests\include;..\
  asm define: Stack_Size=0x4000,Heap_Size=0x20000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
    ../../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
  group User
    ../: test_suite_ecdh.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c
  group mbedtls
    ../../../../Library/CryptoAccelerator/Keil/: mbedcrypto.lib
    ../../../../ThirdParty/mbedtls-3.1.0/tests/src/: helpers.c psa_crypto_helpers.c random.c
