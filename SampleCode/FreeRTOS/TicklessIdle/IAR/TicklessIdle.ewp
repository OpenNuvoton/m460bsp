# IAR project TicklessIdle.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxJHAE series Nuvoton M46xxJHAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\m460\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: TicklessIdle.bin
  ILINK.IlinkOutputFile: TicklessIdle.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group System
    ../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_M460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group Common Demo Tasks
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: blocktim.c countsem.c dynamic.c QueueOverwrite.c QueueSet.c recmutex.c
  group FreeRTOS source
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM4F/: portasm.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c rtc.c sys.c uart.c
  group Demo App Source
    ../: FreeRTOSConfig.h main.c ParTest.c port_iar.c
