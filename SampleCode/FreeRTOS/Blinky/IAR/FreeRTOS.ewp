# IAR project FreeRTOS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxJHAE series Nuvoton M46xxJHAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M460\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; ..; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: FreeRTOS.bin
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_M460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group FreeRTOS files
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: flash.c PollQ.c QueueSet.c
    ../: main.c ParTest.c
