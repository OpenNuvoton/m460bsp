# Keil uVision project HSUSBH_USBH_Firmware_Update.uvprojx, settings and files
target HSUSBH_USBH_Firmware_Update (6150000::V6.15::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.15
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: HSUSBH_USBH_Firmware_Update
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\Library\UsbHostLib\inc
  asm define: Stack_Size=0x800 Heap_Size=0x4000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\usbh_firmware_update.sct
  link misc: --map  --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
  group User
    ../: main.c diskio.c usbh_update.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c fmc.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: usb_core.c hub.c ohci.c ehci.c ehci_iso.c mem_alloc.c
  group UsbHostLib_MSC
    ../../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
  group ThirdParty_FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c
