# Keil uVision project Loader.uvprojx, settings and files
target Loader (6220000::V6.22::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DEV.1.0.0
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: loader +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=5
  c include: ..\..\..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\common\inc;..\..\..\..\..\Library\NuMaker\xmodem
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
    ../../../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
  group User
    ../: main.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c fmc.c wdt.c
    ../../../../../Library/NuMaker/xmodem/: xmodem.c
