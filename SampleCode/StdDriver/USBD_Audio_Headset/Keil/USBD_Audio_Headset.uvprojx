# Keil uVision project USBD_Audio_Headset.uvprojx, settings and files
target USBD_Audio_Headset (6150000::V6.15::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.15
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: USBD_Audio_Headset
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
  group User
    ../: descriptors.c main.c usbd_audio.c config_pdma.c audio_codec.c resample.c hid.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c usbd.c i2c.c i2s.c retarget.c timer.c uart.c pdma.c gpio.c
