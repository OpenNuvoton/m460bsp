# Keil uVision project I2S_WAVPLAYER.uvprojx, settings and files
target I2S_WAVPLAYER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: I2S_WAVPLAYER
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FATFS\source
  asm define: Stack_Size=0x4000 Heap_Size=0x1000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
  group Source
    ../: main.c diskio.c wavplayer.c isr.c sdglue.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c i2s.c i2c.c clk.c uart.c retarget.c pdma.c sdh.c gpio.c
  group FATFS
    ../../../../ThirdParty/FATFS/source/: ff.c
