<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CANFD_CANFD_Loopback.ewp</path>
  </project>
  <batchBuild/>
</workspace>


