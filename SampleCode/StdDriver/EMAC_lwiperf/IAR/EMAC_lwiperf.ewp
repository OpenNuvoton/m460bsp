# IAR project EMAC_lwiperf.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxJHAE series Nuvoton M46xxJHAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082,Pe177,Pe549
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\m460\Include; ..\..\..\..\Library\StdDriver\inc; ..\include; ..\..\..\..\ThirdParty\lwIP\src\include; ..\drv_emac
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EMAC_lwiperf.bin
  ILINK.IlinkOutputFile: EMAC_lwiperf.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_M460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group drv_emac
    ../drv_emac/: m460_emac.c m460_mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group LwIP
    ../../../../ThirdParty/lwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwIP/src/netif/: ethernet.c
    ../../../../ThirdParty/lwIP/src/apps/lwiperf/: lwiperf.c
  group User
    ../: main.c queue.c sys_arch.c
