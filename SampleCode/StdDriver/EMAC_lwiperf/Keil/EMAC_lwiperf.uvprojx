# Keil uVision project EMAC_lwiperf.uvprojx, settings and files
target EMAC_lwiperf (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0xFFFFF) CLOCK(200000000) CPUTYPE("Cortex-M4") FPU2
  output: EMAC_lwiperf
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=177,111,66
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\..\Library\StdDriver\inc;..\drv_emac;..\include;..\..\..\..\ThirdParty\lwIP\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group User
    ../: main.c queue.c sys_arch.c
  group drv_emac
    ../drv_emac/: m460_emac.c m460_emac_process.c m460_mii.c synopGMAC_Dev.c synopGMAC_network_interface.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c timer.c
  group LwIP
    ../../../../ThirdParty/lwIP/src/apps/lwiperf/: lwiperf.c
    ../../../../ThirdParty/lwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwIP/src/netif/: ethernet.c
