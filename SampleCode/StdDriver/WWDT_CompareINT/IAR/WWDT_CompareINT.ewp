# IAR project WWDT_CompareINT.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxJHAE series Nuvoton M46xxJHAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M460\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WWDT_CompareINT.bin
  ILINK.IlinkOutputFile: WWDT_CompareINT.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_M460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c wwdt.c
  group User
    ../: main.c
