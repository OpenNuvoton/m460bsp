# Keil uVision project SDH_FATFS.uvprojx, settings and files
target SDH_FATFS (6120000::V6.12::.\ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: sdh_fatfs
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FatFs\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
    ../../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
  group User
    ../: main.c diskio.c SDGlue.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c sdh.c gpio.c timer.c
  group FATFS
    ../../../../ThirdParty/FatFs/source/: ff.c
