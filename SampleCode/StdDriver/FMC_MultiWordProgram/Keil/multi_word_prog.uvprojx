# Keil uVision project multi_word_prog.uvprojx, settings and files
target multi_word_prog (6190000::V6.19::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DEV.1.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: multi_word_prog
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: sram.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
    ../../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
  group User
    ../: multi_word_prog.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c fmc.c
