# IAR project main_loader.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxJHAE series Nuvoton M46xxJHAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\m460\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: main_loader.bin
  ILINK.IlinkOutputFile: main_loader.out
  ILINK.IlinkExtraOptions: --image_input Release\Exe\multi_word_prog.bin,loaderImage1Base,.bin_image,4; --image_input Release\Exe\multi_word_prog.bin,loaderImage1Limit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_M460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: main_loader.c
