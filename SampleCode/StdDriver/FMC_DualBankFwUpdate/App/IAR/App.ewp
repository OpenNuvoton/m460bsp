# IAR project App.ewp, settings and files
configuration App (ARM)
  General.OGChipSelectEditMenu: M46xxIHAE series Nuvoton M46xxIHAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Nuvoton\m460\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\common\inc; ..\..\..\..\..\Library\NuMaker\xmodem
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: App.bin
  ILINK.IlinkOutputFile: App.out
  ILINK.IlinkIcfFile: m460.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration NewApp (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NewApp
  OBJCOPY.OOCOutputFile: NewApp.bin
  ILINK.IlinkOutputFile: NewApp.out
  group CMSIS
    ../../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_M460.s
    ../../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
    ../../../../../Library/NuMaker/xmodem/: xmodem.c
  group User
    ../: main.c
