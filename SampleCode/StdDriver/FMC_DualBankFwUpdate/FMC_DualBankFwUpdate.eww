<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$\App\IAR\App.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Loader\IAR\Loader.ewp</path>
    </project>
</workspace>


