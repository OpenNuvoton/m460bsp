# Keil uVision project QSPI_QuadMode_Flash.uvprojx, settings and files
target QSPI_QuadMode_Flash (6220000::V6.22::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DEV.1.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: QSPI_QuadMode_Flash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_m460.s
  group Library
    ../../../../Library/StdDriver/src/: uart.c clk.c retarget.c sys.c gpio.c qspi.c
  group User
    ../: main.c
