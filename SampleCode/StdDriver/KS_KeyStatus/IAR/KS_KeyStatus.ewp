# IAR project KS_KeyStatus.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxGCAE series Nuvoton M46xxGCAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M460\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KS_AESKey.bin
  ILINK.IlinkOutputFile: RTC_Alarm_Test.out
  ILINK.IlinkIcfFile: M460.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_M460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_M460.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c crypto.c keystore.c retarget.c sys.c uart.c
  group User
    ../: main.c
