# IAR project CCAP_Packet_DownScale.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxJHAE series Nuvoton M46xxJHAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\library\Device\Nuvoton\m460\Include; $PROJ_DIR$..\..\..\..\..\library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CCAP_Packet_DownScale.bin
  ILINK.IlinkOutputFile: CCAP_Packet_DownScale.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_M460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
  group Library
    ../../../../Library/StdDriver/src/: ccap.c clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: i2c_gpio.c main.c Sensor_nt99141.c
