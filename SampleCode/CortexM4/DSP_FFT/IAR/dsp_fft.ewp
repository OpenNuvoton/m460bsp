# IAR project dsp_fft.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M46xxGCAE series Nuvoton M46xxGCAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4=1UL; __FPU_PRESENT=1UL
  ICCARM.CCDiagSuppress: Pa082, Pa093
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M460\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dsp_fft.bin
  ILINK.IlinkOutputFile: dsp_fft.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Library\CMSIS\Lib\ARM\arm_cortexM4lf_math.lib
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/IAR/: startup_M460.s
    ../../../../Library/Device/Nuvoton/m460/Source/: system_M460.c
  group Library
    ../../../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: arm_fft_bin_data.c main.c
