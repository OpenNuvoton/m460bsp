# Keil uVision project dsp_fft.uvproj, settings and files
target dsp_fft (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: M467HJHAE Nuvoton
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0xFFFFF) CLOCK(200000000) CPUTYPE("Cortex-M4") FPU2
  output: dsp_fft
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4=1, __FPU_PRESENT=1UL
  c include: ..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_M460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
  group User
    ../: main.c arm_fft_bin_data.c
  group Library
    ../../../../Library/StdDriver/src/: fmc.c retarget.c uart.c clk.c sys.c
    ../../../../Library/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
