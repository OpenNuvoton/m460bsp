# Keil uVision project BitBand.uvprojx, settings and files
target BitBand (6190000::V6.19::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0xFFFFF) CLOCK(200000000) CPUTYPE("Cortex-M4") FPU2
  output: BitBand
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M460\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_M460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M460/Source/ARM/: startup_M460.s
    ../../../../Library/Device/Nuvoton/M460/Source/: system_M460.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c
  group User
    ../: main.c
